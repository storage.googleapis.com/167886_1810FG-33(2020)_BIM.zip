Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView_V2.0]
File name: 0001
Time: 2020-07-14T17:57:23
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 20190508_0315(x64) - Exporter 17.4.0.0 - Alternate UI 17.4.0.0
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Tue Jul 14 17:57:23 2020 * Host: DESKTOP-JLKK7TQ * Database: C:\Users\vladb\AppData\Local\Temp\{AA6F53C6-3C1A-405E-A2BD-B6B55A87C0E6}\ifc * Database version: 5507 * Database creation date: Tue Jul 14 17:57:22 2020 * Schema: IFC2X3 * Model: DataRepository.ifc * Model creation date: Tue Jul 14 17:57:22 2020 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Tue Jul 14 17:57:22 2020 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcProject, 0001
LongName: Project Name; Phase: Project Status

# IfcSite, Default
RefLatitude: 42, 21, 31, 181945; RefLongitude: -71, -3, -24, -263305; RefElevation: 0 mm
Other - Category: Project Information; Client Name: Owner; Project Address: Enter address here; Project Issue Date: Issue Date; Project Name: Project Name; Project Number: 0001; Project Status: Project Status

# IfcBuilding
Pset_BuildingCommon - NumberOfStoreys: 1
Other - Category: Project Information; Client Name: Owner; Project Address: Enter address here; Project Issue Date: Issue Date; Project Name: Project Name; Project Number: 0001; Project Status: Project Status

# IfcBuildingStorey, Level 1
LongName: Level 1; Elevation: 0 mm
Other(Type) - Category: Levels; Family Name: Level
Identity Data(Type) - Type Name: 8mm Head
Constraints - Elevation: 0 mm
Dimensions - Computation Height: 0 mm
Identity Data - Building Story: yes; Name: Level 1; Structural: no
Other - Category: Levels; Family: Level: 8mm Head; Family and Type: Level: 8mm Head; Type: Level: 8mm Head; Type Id: Level: 8mm Head
Constraints(Type) - Elevation Base: Project Base Point
Graphics(Type) - Color: 0; Line Pattern: Centre; Line Weight: 1; Symbol: M_Level Head - Circle: M_Level Head - Circle; Symbol at End 1 Default: no; Symbol at End 2 Default: yes

# IfcFlowController: 1810FG-33 Washbasin faucet, 1810FG-33(2020):1810FG-33 Washbasin faucet:323218
In: Level 1
Type - PredefinedType: FAUCET; Material: Brass
Type - Dimensions(Type) - InletConnectionSize: 10 mm; NominalDepth: 144.5 mm; NominalHeight: 151 mm; NominalWidth: 49.9 mm; Projection: 107 mm
Type - General(Type) - Author: Convergo AB; BIMObjectName: 1810FG-33(2020); ConvergoRefNr: 0087-2006-0049-FI; ManufacturerName: Oras; ManufacturerURL: http://www.oras.com; NBSDescription: Water supply fittings for wash basins and troughs; NBSReference: 45-35-70/371; ProductInformation: Washbasin faucet; Revision: n/a; Uniclass2: Pr_40_30_96_96; Uniclass2015Description: Washbasin manual water supply sets; Uniclass2015Reference: Pr_40_20_87_96; Version: 1; VersionDate: 09/07/2020
Type - Green Building Properties(Type) - Backflow Prevention EN1717: AA; Customs Code: 84818011; EAN Number: 6414150097621; EN Standard: EN 817; LVI Number: 6110331
Type - Identity Data(Type) - Catalog Drawing URL: http://static.oras.com/catdrw/1810FG-33; Class: Single lever; Dimension Drawing URL: http://static.oras.com/dimdrw/1810FG-33; FDV Document URL: http://www.oras.com/datasheet/1810FG-33/en/fdv; Flow Drawing URL: http://static.oras.com/flowchart/1810FG-33; Group: Washbasin faucets; Manufacturer: Oras; Model: 1810FG-33 Washbasin faucet; Name_en: 1810FG-33 Washbasin faucet; OmniClass Number: 23.45.55.00; OmniClass Title: Sanitary Faucets, Wastes; Package external Dimensions: 540 x 146 x 59; Package Weight: 1.37 kg; Product Code: 1810FG-33; Product Datasheet: http://www.oras.com/datasheet/1810FG-33/en; Product Family: Oras Vega; Product Image URL: http://static.oras.com/image/1810FG-33; Product URL: http://static.oras.com/1810FG-33; Technical DataSheet URL: http://www.oras.com/datasheet/1810FG-33/en; Type Name: 1810FG-33 Washbasin faucet
Type - Materials and Finishes(Type) - FaucetMainMaterial: Brass
Type - Mechanical(Type) - Advanced Features: 3S-Installation; Aerator: CASCADE®; Connection: FlexibleInletPipes; Connection Size: G3/8; DN Size: DN 15; Eco Flow At 300kPa: 0.00388461 m3/s; Extensions: ChainHolder; Flow Rate At 300kPa: 0.00635664 m3/s; Installation and Maintenance: http://static.oras.com/manual/1810FG-33; Installation Type: Deck mounted; Lever Handle: Lever with H+C symbol; Max. Hot Water Supply: 80 kg/K/s3; Mechanical Parts: 40Cartridge; Mounting Holes: 1MountingHole; Noise Class: I (ISO 3822); Pressure Loss With Flow 01ls: 110000 Pa; Spare Parts: http://static.oras.com/sp/1810FG-33; Spout Type: Fixed spout; Temperature Adjustments: Temperature limiter
Type - Other(Type) - AccessibilityPerformance: n/a; AssetType: Fixed; Brand: Oras; Category: Bathroom; CodePerformance: n/a; Color: Chrome; Constituents: n/a; DurationUnit: Year; ExpectedLife: n/a; Family Name: 1810FG-33(2020); Features: Single lever; Finish: Polished; Grade: n/a; Material: Brass; ModelNumber: n/a; ModelReference: 1810FG-33; Name: 1810FG-33 Washbasin faucet; ReplacementCost: n/a; Shape: Sculptured; Size: 50x145x150 mm; SustainabilityPerformance: n/a; WarrantyDescription: http://warranty.oras.com; WarrantyDurationLabor: n/a; WarrantyDurationParts: n/a; WarrantyDurationUnit: Year; WarrantyGuarantorLabor: n/a; WarrantyGuarantorParts: n/a
Pset_ManufacturerTypeInformation - ModelReference: 1810FG-33; Manufacturer: Oras
Pset_DistributionFlowElementCommon - Reference: 1810FG-33 Washbasin faucet
Constraints - DefaultElevation: 900 mm; Host: Level : Level 1; Level: Level: Level 1; Offset: 0 mm
Dimensions - Area: 0.0376838 m2; Volume: 0.00109449 m3
Identity Data - Mark: 3
Mechanical - System Classification: Domestic Hot Water,Domestic Cold Water
Other - AssetIdentifier: n/a; Barcode: n/a; Category: Plumbing Fixtures; Family: 1810FG-33(2020): 1810FG-33 Washbasin faucet; Family and Type: 1810FG-33(2020): 1810FG-33 Washbasin faucet; InstallationDate: n/a; SerialNumber: n/a; TagNumber: n/a; Type: 1810FG-33(2020): 1810FG-33 Washbasin faucet; Type Id: 1810FG-33(2020): 1810FG-33 Washbasin faucet; WarrantyStartDate: n/a
Phasing - Phase Created: New Construction
